# Keil uVision project BH-F103.uvprojx, settings and files
target BYSJ_XJX (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BYSJ_XJX +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Library\CMSIS;..\Library\STM32F10x_StdPeriph_Driver\inc;..\Led;..\Wifi;..\Ultrasonic;..\Usart;..\Motor;..\System\delay;..\System\sys;..\OV7725
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Library/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Library/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../System/delay/: delay.c
    ../System/sys/: sys.c
  group LED
    ../Led/: led.c
  group WIFI
    ../Wifi/: wifi.c M8266HostIf_STM32xx.c M8266WIFI_Ops.c M8266WIFIDrv_STM32F1xx.lib
  group ULTRASONIC
    ../Ultrasonic/: ultrasonic.c
  group USART
    ../Usart/: usart.c
  group MOTOR
    ../Motor/: motor.c
  group OV
    ../OV7725/: ov7725.c sccb.c
  group USER
    ../User/: main.c stm32f10x_it.c
  group DOC
    ../Doc/: ReadMe.txt
